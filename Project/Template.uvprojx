# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,SYSCLK_FREQ_72MHz
  c include: ..\STM32F10x_FWLib\core;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib;..\LiteOS\LiteOS\osdepends\liteos;..\LiteOS\LiteOS\include;..\LiteOS\LiteOS\kernel\base\include;..\LiteOS\LiteOS\kernel\include;..\LiteOS\LiteOS\OS_CONFIG;..\LiteOS\LiteOS\kernel\extended\include;..\LiteOS\LiteOS\arch\arm\common\cmsis;..\LiteOS\LiteOS\arch\arm\arm-m\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
  group FWLib
    ../STM32F10x_FWLib/: system_stm32f10x.c
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../STM32F10x_FWLib/core/: startup_stm32f10x_hd.s
  group LiteOS/arch
    ../LiteOS/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../LiteOS/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group LiteOS/kernel
    ../LiteOS/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../LiteOS/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../LiteOS/LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/LiteOS/kernel/extended/tickless/: los_tickless.c
    ../LiteOS/LiteOS/kernel/: los_init.c
